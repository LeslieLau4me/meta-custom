# 移除所有 MySQL/MariaDB 相关功能
PACKAGECONFIG:remove = "mysql mysqli pdo-mysql"
