# 本地文件，不走网络
#SRC_URI = "file://${DL_DIR}/redis-plus-plus-1.3.11.tar.gz"
# SRC_URI[sha256sum] = "bb4990eed60d3654cd6902b9e67b3ab43e52557e84315560660b0c9e64b6ff77"
# S = "${WORKDIR}/redis-plus-plus-1.3.11"
